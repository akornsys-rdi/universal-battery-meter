# Repository akornsys-rdi/universal-battery-meter

File README.md:

# universal-battery-meter #

### Universal Battery Meter ###

     _   _ ___ __  __   
    | | | | _ )  \/  |  
    | |_| | _ \ |\/| |  
     \___/|___/_|  |_|  

Project developed by [kwendenarmo](http://kwendenarmo.es/ "kwendenarmo") (<devel@kwendenarmo.es>).  
This project is under GPLv3 licence. See COPYING file.  
See CHANGELOG file to check the history of dates, versions and changes.  
README.md file.  

## Version ##

Versión 2.0.0 "devel"

## Cambios ##

Reimplementación del branch `old-v1`, con funcionalidades añadidas:

- Hardware dividido en tres bloques:
    * Display
        + Muestra datos a través de cuatro display 7seg.
        + Cuatro LED de modo (*V*, *A*, *W, *ºC*) para indicar qué tipo de dato se está mostrando en display. (`DK6`: `DC`-`DF`)
        + Dos LED de tipo de visualización (instantáneo o a la hora). (`DK6`: `DG`-`DDP`)
        + Cuatro LED de sonda activa. (`DK7`: `DA`-`DD`)
        + Tres LED de indicación de salida (`OUT_CHARGE`, `OUT_DISCHARGE`, `IMPULSE`). (`DK7`: `DE`-`DG`)
        + Diez led para escala analógica (RGGGGYYYRR). (`DK5`: `DA`-`DDP`; `DK6`: `DA`-`DB`)
        + Un buzzer con soporte para tonos.
        + Tres pulsadores (unit, set, mode) que permite cambiar la unidad mostrada en display y modificar la configuración de control.
        + El display usa entrada de 9 pines: `DS_VCC`, `DS_MOSI`, `DS_SCK`, `DS_SS`, `DS_BUZ`, `DS_UNT`, `DS_MOD`, `DS_SET`, `DS_GND`. VCC de 5V
        + Todos los LED (7seg e individuales) van multiplexados a través de SPI (Primer byte ánodo, Segundo byte cátodos comunes).
        + El sistema incluye un power-on-reset para limpiar los registros del SPI.
        + La entrada del buzzer se ataca directamente a través de un fet.
        + Los tres pulsadores llevan un anti-rebotes por hardware.
    * Control
        + Basado en ATmega328 a 16MHz
        + Conexión directa al display, mediante zócalo.
        + Cabecera de ISP.
        + EEPROM SPI (bus compartido) para log.
        + Conector de salidas de drenador abierto para media potencia. Salidas: `STAT_FULL`, `STAT_FLOAT`, `STAT_FAIL`, `OUT_CHARGE`, `OUT_DISCHARGE`, `IMPULSE`.
        + Conector de comunicaciones mediante RS485 con pull y terminador. Válido para programación.
        + Conector de sonda mediante RS485 con pull y terminador. Incorpora alimentación regulada.
        + Permite múltiples sondas en cascada.
        + Autodetección de la sonda.
        + Selección de alimentación a través de módulo o desde sonda.
        + Monitorización de tensiones en entrada y VCC
    * Sonda
        + Módulos en rangos de tensión y corriente admitida.
        + Basado en ATmega 328 a 16MHz
        + Conexión RS485 con el módulo principal. Válido para programación.
        + Selector de terminador.
        + Conector de sonda para sondas en cascada.
        + Medida de tensión.
        + Medida de corriente.
        + Conector para sonda de temperatura.
        + Sensor de temperatura incorporado en el cuerpo de la sonda para medida diferencial.
        + Preamplificadores operacionales anteriores al ADC.

Usos:
- Logger
- Charger
- Discharger
- Monitor
- Voltmeter
- Ammeter
- Capacity meter
- Energy meter

Librerias:
- datelib
- modbus??

Formfactor:
- panel (http://img-asia.electrocomponents.com/largeimages/R6876140-01.jpg)

## KiCad design brd/display/display.kicad_pcb

Parts:
C1, C8: 100nF; C_0805_HandSoldering
C3, C4: 10nF; C_0805_HandSoldering
C5, C6, C9: 1uF; C_0805_HandSoldering
C7: 10uF; c_elec_4x5.3
D1: 1N914; Diode_SOT23_Handsoldering
D3, D11, D12, D13, D14, D15, D16: RED; LED-0805
D4, D5, D6, D7: GREEN; LED-0805
D8, D9, D10: YELLOW; LED-0805
DS1, DS2, DS3, DS4: SC56-11EWA; 41SRWA
LS1: BUZZER; AST1575BMATRQ
P1: CONN_01X09; Pin_Header_Straight_1x09
Q1, Q2, Q3, Q4, Q5, Q6, Q7: 2N7002; sot23
R1, R26, R27, R29, R30: 10k; R_0805_HandSoldering
R2, R12, R14, R16, R18, R20, R22: 100R; R_0805_HandSoldering
R3, R13, R15, R17, R19, R21, R23: 100k; R_0805_HandSoldering
R4, R5, R6, R7, R8, R9, R10, R11: 220R; R_0805_HandSoldering
R24, R25, R28: 560R; R_0805_HandSoldering
SW1, SW2, SW3: SW_PUSH; SKQG-180836
U1, U2: 74HC595; SOIC-16_3.9x9.9mm_Pitch1.27mm

Connections:
/da: D3.1 (A), D11.1 (A), DS1.7, DS2.7, DS3.7, DS4.7, R4.1
/db: D4.1 (A), D12.1 (A), DS1.6, DS2.6, DS3.6, DS4.6, R5.1
/dc: D5.1 (A), D13.1 (A), DS1.4, DS2.4, DS3.4, DS4.4, R6.1
/dd: D6.1 (A), D14.1 (A), DS1.2, DS2.2, DS3.2, DS4.2, R7.1
/ddp: D10.1 (A), DS1.5, DS2.5, DS3.5, DS4.5, R11.1
/de: D7.1 (A), D15.1 (A), DS1.1, DS2.1, DS3.1, DS4.1, R8.1
/df: D8.1 (A), D16.1 (A), DS1.9, DS2.9, DS3.9, DS4.9, R9.1
/dg: D9.1 (A), DS1.10, DS2.10, DS3.10, DS4.10, R10.1
/dk1: DS1.3, DS1.8, Q2.3 (D)
/dk2: DS2.3, DS2.8, Q3.3 (D)
/dk3: DS3.3, DS3.8, Q4.3 (D)
/dk4: DS4.3, DS4.8, Q5.3 (D)
/dk5: D3.2 (K), D4.2 (K), D5.2 (K), D6.2 (K), D7.2 (K), D8.2 (K), D9.2 (K), D10.2 (K)
/dk6: D11.2 (K), D12.2 (K), D13.2 (K), D14.2 (K), D15.2 (K), D16.2 (K), Q7.3 (D)
DS_BUZ: P1.5, R2.1
DS_GND: C1.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, P1.9, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), Q7.2 (S), R3.2, R13.1, R15.1, R17.1, R19.1, R21.1, R23.1, R24.2, R25.2, R28.2, U1.8 (GND), U1.13 (G), U2.8 (GND), U2.13 (G); also elsewhere on the board
DS_MOD: C9.1, P1.7, R29.2, SW3.2
DS_MOSI: P1.2, U1.14 (SER)
DS_SCK: P1.3, U1.11 (SRCLK), U2.11 (SRCLK)
DS_SET: C6.1, P1.8, R27.2, SW2.2
DS_SS: P1.4, U1.12 (RCLK), U2.12 (RCLK)
DS_UNT: C5.1, P1.6, R26.2, SW1.2
DS_VCC: C3.1, C4.1, C7.1, C8.1, D1.3 (K), LS1.1, P1.1, R1.2, R26.1, R27.1, R29.1, R30.1, U1.16 (VCC), U2.16 (VCC)
unnamed: C1.2, D1.1 (A), R1.1, U1.10 (SRCLR), U2.10 (SRCLR)
unnamed: LS1.2, Q1.3 (D), R30.2
unnamed: Q1.1 (G), R2.2, R3.1
unnamed: Q2.1 (G), R12.1, R13.2
unnamed: Q3.1 (G), R14.1, R15.2
unnamed: Q4.1 (G), R16.1, R17.2
unnamed: Q5.1 (G), R18.1, R19.2
unnamed: Q6.1 (G), R20.1, R21.2
unnamed: Q7.1 (G), R22.1, R23.2
unnamed: R4.2, U1.15 (QA)
unnamed: R5.2, U1.1 (QB)
unnamed: R6.2, U1.2 (QC)
unnamed: R7.2, U1.3 (QD)
unnamed: R8.2, U1.4 (QE)
unnamed: R9.2, U1.5 (QF)
unnamed: R10.2, U1.6 (QG)
unnamed: R11.2, U1.7 (QH)
unnamed: R12.2, U2.15 (QA)
unnamed: R14.2, U2.1 (QB)
unnamed: R16.2, U2.2 (QC)
unnamed: R18.2, U2.3 (QD)
unnamed: R20.2, U2.4 (QE)
unnamed: R22.2, U2.5 (QF)
unnamed: R24.1, SW1.1
unnamed: R25.1, SW2.1
unnamed: R28.1, SW3.1
unnamed: U1.9 (~QH), U2.14 (SER)

Board: 2 copper layers, 74 parts (36 on the bottom side), 50 nets, no tracks yet.

Other parts of the board:
Measurement_Point_Round-SMD-Pad_Big: VAL**; Measurement_Point_Round-SMD-Pad_Big
Measurement_Point_Round-SMD-Pad_Big#2: VAL**; Measurement_Point_Round-SMD-Pad_Big
Symbol_OSHW-Logo_SilkScreen: VAL**; Symbol_OSHW-Logo_SilkScreen

Their connections:
DS_GND: Measurement_Point_Round-SMD-Pad_Big.1, Measurement_Point_Round-SMD-Pad_Big#2.1; also elsewhere on the board

## KiCad design brd/control/control.kicad_pcb

Parts:
C1: 100nF; C_0805_HandSoldering
C2: 100uF; c_elec_6.3x5.3
C3: 10uF; c_elec_4x5.3
C4, C6, C9, C10, C11: 10nF; C_0805_HandSoldering
C5: 330nF; C_0805_HandSoldering
C7, C8: 22pF; C_0805_HandSoldering
P1: POWER; Socket_MOLEX-KK-RM2-54mm_Lock_2pin_straight
P2: PSU; Pin_Header_Straight_1x03
P3: DISPLAY; Pin_Header_Angled_1x09
P4: RS485; Socket_MOLEX-KK-RM2-54mm_Lock_3pin_straight
P5: PROBE; Socket_MOLEX-KK-RM2-54mm_Lock_4pin_straight
P6: OUTS
Q1, Q2, Q3, Q4, Q5: IRLML2060; sot23
R1: 3k3; R_0805_HandSoldering
R2: 47k; R_0805_HandSoldering
R3: 5k6; R_0805_HandSoldering
R4: 27k; R_0805_HandSoldering
R5, R6: 10R; R_0805_HandSoldering
R7: 10k; R_0805_HandSoldering
R8, R9, R10, R11: 680R; R_0805_HandSoldering
R12, R13: 120R; R_0805_HandSoldering
R14, R16, R18, R20, R22: 100R; R_0805_HandSoldering
R15, R17, R19, R21, R23: 100k; R_0805_HandSoldering
U1: ATMEGA328-A; TQFP-32_7x7mm_Pitch0.8mm
U2: 25LC1024; SOIJ-8_5.3x5.3mm_Pitch1.27mm
U3, U4: MAX13487; SOIJ-8_5.3x5.3mm_Pitch1.27mm
X1: 16MHz; Q_49U3HMS

Connections:
+5V: C3.1, C5.1, C6.1, C9.1, C10.1, C11.1, P2.3, P3.1, P5.4, R1.2, R5.1, R7.1, R8.1, R9.1, U1.4 (VCC), U1.6 (VCC), U2.3 (~WP), U2.7 (~HOLD), U2.8 (VCC), U3.2 (~RE), U3.3 (~SHDN), U3.8 (VCC), U4.2 (~RE), U4.3 (~SHDN), U4.8 (VCC)
+5VA: C4.1, R5.2, U1.18 (AVCC)
AGND: C1.2, C4.2, R6.2, U1.21 (GND)
GND: C2.2, C3.2, C5.2, C6.2, C7.1, C8.1, C9.2, C10.2, C11.2, P1.2, P2.2, P3.9, P4.1, P5.1, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), R3.2, R4.2, R6.1, R10.2, R11.2, R15.1, R17.1, R19.1, R21.1, R23.1, U1.3 (GND), U1.5 (GND), U2.4 (VSS), U3.5 (GND), U4.5 (GND)
unnamed: C1.1, U1.20 (AREF)
unnamed: C7.2, U1.7 ((PCINT6/XTAL1/TOSC1)PB6), X1.1
unnamed: C8.2, U1.8 ((PCINT7/XTAL2/TOSC2)PB7), X1.2
unnamed: P3.2, U1.15 ((PCINT3/OC2A/MOSI)PB3), U2.5 (SI)
unnamed: P3.3, U1.17 ((PCINT5/SCK)PB5), U2.6 (SCK)
unnamed: P3.4, U1.23 ((PCINT8/ADC0)PC0)
unnamed: P3.5, U1.13 ((PCINT1/OC1A)PB1)
unnamed: P3.6, U1.14 ((PCINT2/OC1B/~SS~)PB2)
unnamed: P3.7, U1.25 ((PCINT10/ADC2)PC2)
unnamed: P3.8, U1.24 ((PCINT9/ADC1)PC1)
unnamed: P4.2, R10.1, R13.2, U3.7 (B)
unnamed: P4.3, R8.2, R13.1, U3.6 (A)
unnamed: P5.2, R11.1, R12.2, U4.7 (B)
unnamed: P5.3, R9.2, R12.1, U4.6 (A)
unnamed: P6.1, Q1.3 (D)
unnamed: P6.2, Q2.3 (D)
unnamed: P6.3, Q3.3 (D)
unnamed: P6.5, Q4.3 (D)
unnamed: P6.6, Q5.3 (D)
unnamed: Q1.1 (G), R14.1, R15.2
unnamed: Q2.1 (G), R16.1, R17.2
unnamed: Q3.1 (G), R18.1, R19.2
unnamed: Q4.1 (G), R20.1, R21.2
unnamed: Q5.1 (G), R22.1, R23.2
unnamed: R1.1, R4.1, U1.19 (ADC6)
unnamed: R2.1, R3.1, U1.22 (ADC7)
unnamed: R7.2, U1.29 ((PCINT14/~RESET~)PC6)
unnamed: R14.2, U1.26 ((PCINT11/ADC3)PC3)
unnamed: R16.2, U1.27 ((PCINT12/SDA/ADC4)PC4)
unnamed: R18.2, U1.28 ((PCINT14/SCL/ADC5)PC5)
unnamed: R20.2, U1.10 ((PCINT22/OC0A/AIN0)PD6)
unnamed: R22.2, U1.11 ((PCINT23/AIN1)PD7)
unnamed: U1.1 ((PCINT19/OC2B/INT1)PD3), U4.4 (DI)
unnamed: U1.12 ((PCINT0/CLKO/ICP1)PB0), U2.1 (~CS)
unnamed: U1.16 ((PCINT4/MISO)PB4), U2.2 (SO)
unnamed: U1.30 ((PCINT16/RXD)PD0), U3.1 (RO)
unnamed: U1.31 ((PCINT17/TXD)PD1), U3.4 (DI)
unnamed: U1.32 ((PCINT18/INT0)PD2), U4.1 (RO)
VCOM: C2.1, P1.1, P2.1, P6.4, P6.7, R2.2

Board: 2 copper layers, 49 parts (0 on the bottom side), 38 nets, no tracks yet.

## Commit log

2014-03-23 added brd & src files
2014-03-23 COPYING file
2014-06-21 bug found!
2015-02-05 version 2
2015-03-02 listed features
2015-12-06 chg: dev: backup !wip
